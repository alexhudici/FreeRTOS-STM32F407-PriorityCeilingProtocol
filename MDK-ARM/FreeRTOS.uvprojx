# Keil uVision project FreeRTOS.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: FreeRTOS
  c flags: Optim=1
  c define: ARM_MATH_CM4 USE_STDPERIPH_DRIVER STM32F40XX __FPU_PRESENT=1
  c include: ..\..\CORTEX_M4F_STM32F407ZG-SK;..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\demo-includes\include;..\STM32F4-Discovery;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM4F;..\..\FreeRTOS-STM32F407VG
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group main
    ../: main.c ParTest.c stm32f4xx_it.c RegTest.s
    ../demo-includes/Minimal/: death.c integer.c semtest.c recmutex.c PollQ.c GenQTest.c flop.c flash.c dynamic.c countsem.c blocktim.c BlockQ.c
    ./: DebugOut.c
  group STM32F4-Discovery
    ../STM32F4-Discovery/: stm32f4_discovery.c
  group FreeRTOS
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../FreeRTOS/portable/MemMang/: heap_2.c
  group port
    ../FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
  group STM32F4xx_StdPeriph_Driver
    ../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c
  group ::Device
    RTE/Device/STM32F407VG/: RTE_Device.h startup_stm32f40xx.s system_stm32f4xx.c
software components: CMSIS:CORE 3.20.0, Device:Startup 1.0.0
